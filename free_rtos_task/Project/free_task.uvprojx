# Keil uVision project free_task.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: free_test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\freertos\Source\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group freertos/ports
    ../freertos/Source/portable/RVDS/ARM_CM3/: port.c
  group user
    ../User/: main.c
  group freertos/source
    ../freertos/Source/Source/: list.c task.c
software components: CMSIS:CORE 5.2.0, Device:Startup 1.1.0
